# Keil uVision project ledblink.uvproj, settings and files
target ledblink (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: ledblink +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc;.\stc;.\middleware
  group Startup
    ./: STARTUP.A51
  group User
    ./src/: main.c
    ./middleware/: delay.c
